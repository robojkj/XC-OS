# Keil uVision project XC-OS.uvprojx, settings and files
target XC-OS (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F429VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: XC-OS +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ../MDK-ARM/Objects/@L.bin  ../MDK-ARM/Objects/@L.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARDUINO=111,LV_CONF_INCLUDE_SIMPLE,STM32F429_439xx
  c misc: --gnu
  c include: ..\ArduinoAPI;..\Core;..\Libraries\lvgl\lv_examples;..\Libraries\FreeRTOS;..\Libraries\FreeRTOS\Source\include;..\Libraries\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Libraries\lua-5.3.2\src;..\Libraries\SdFat\src;..\XC-OS;..\XC-OS\GUI;..\Libraries\Adafruit_GFX_Library;..\Libraries\cm_backtrace;..\Libraries\I2Cdev;..\Libraries\MPU6050;..\Libraries;..\Libraries\lvgl;..\Libraries\BMP280_DEV;..\Libraries\ClosedCube_SHT31D;..\Libraries\SoftwareSPI;..\Core\STM32F4xx_StdPeriph_Driver\inc;..\Core\CMSIS\Include;..\Core\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\FATFS;..\Libraries\mp3\pub;..\Libraries\mp3\real;..\Libraries\mp3
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Basic
    ../XC-OS/Basic/: main.cpp FileGroup.h TasksManage.h SysConfig.h system.c rt_sys.cpp
  group BSP
    ../XC-OS/BSP/: BSP.h BSP_Audio.cpp BSP_Backlight.cpp BSP_IMU.cpp BSP_Motor.cpp BSP_Power.cpp BSP_MemoryPool.cpp BSP_Sensor.cpp BSP_RTC.cpp BSP_Wireless.cpp
  group GUI
    ../XC-OS/GUI/: DisplayPrivate.h DisplayBasic.cpp DisplayBar.cpp DisplayChinese.cpp DisplayDropDownList.cpp DisplayOSState.cpp DisplayAppWin.cpp DisplayError.cpp DisplayWidget.cpp lv_conf.h lv_port_disp.cpp lv_port_fs.cpp lv_ext_func.cpp
  group GUI/Page
    ../XC-OS/GUI/Page/: Page_EXAMPLE.cpp Page_About.cpp Page_BattInfoOld.cpp Page_RadioCfg.cpp
  group GUI/IMG
    ../XC-OS/GUI/IMG/: ImgCode.c ImgEditor.c ImgFiles.c ImgGame.c ImgMessage.c ImgMusic.c ImgPlay.c ImgSettings.c ImgSubApps.c ImgVideo.c ImgTerminal.c ImgBattery.c ImgCPU.c ImgOS.c ImgRAM.c ImgROM.c
  group GUI/Fonts
    ../XC-OS/GUI/Fonts/: simhei.c FontAwesome.c
  group APP/Home
    ../XC-OS/APP/Home/: HomePrivate.h Page_Home.cpp HomeAnim.cpp HomeIcon.cpp
  group APP/BvPlayer
    ../XC-OS/APP/BvPlayer/: Page_BvPlayer.cpp
    ../XC-OS/APP/BvPlayer/BV_Player/: BV_Player.cpp BV_Player.h BvType.h
  group APP/FileExplorer
    ../XC-OS/APP/FileExplorer/: Page_FileExplorer.cpp
  group APP/LuaIDE
    ../XC-OS/APP/LuaIDE/: Page_LuaScript.cpp
  group APP/LuaApp
    ../XC-OS/APP/LuaApp/: Page_LuaAppSel.cpp Page_LuaAppWin.cpp
  group APP/TextEditor
    ../XC-OS/APP/TextEditor/: Page_TextEditor.cpp TextEditorPrivate.h
  group APP/WavPlayer
    ../XC-OS/APP/WavPlayer/: WavPlayer_Private.h Page_WavPlayer.cpp WavPlayer.cpp MusicList.cpp Lyric.cpp FFT.cpp
    ../XC-OS/APP/WavPlayer/WavDecoder/: wav_decoder.cpp
    ../XC-OS/APP/WavPlayer/FastFFT/: FastFFT.cpp
    ../XC-OS/APP/WavPlayer/Lyric_Analyzer/: Lyric_Analyzer.cpp
    ../XC-OS/APP/WavPlayer/MP3Decoder/: mp3_decoder.cpp
  group APP/Shell
    ../XC-OS/APP/Shell/: ShellPrivate.h Page_Shell.cpp Interface_FileSystem.cpp Interface_HW.cpp Interface_Shell.cpp
    ../XC-OS/APP/Shell/Shell/: Shell.c
    ../XC-OS/APP/Shell/XC_COM/: XC_COM.cpp CRC32.c
  group APP/Settings
    ../XC-OS/APP/Settings/: SettingsPrivate.h Page_Settings.cpp SettingsMain.cpp SettingsDisplay.cpp SettingsSound.cpp SettingsBattery.cpp SettingsRadio.cpp SettingsAbout.cpp
    ../XC-OS/APP/Settings/lv_settings/: lv_settings.c
  group APP/SubDev
    ../XC-OS/APP/SubDev/: Page_SubDev.cpp ShellNode.h
  group APP/Game
    ../XC-OS/APP/Game/: Page_GameSelect.cpp Page_Game.cpp GameManager.cpp GameDisp.cpp GamePrivate.h GameDisp.h
  group APP/Game/Arduboy
    ../XC-OS/APP/Game/Arduboy/: Arduboy.cpp Arduboy.h
    ../XC-OS/APP/Game/Arduboy/core/: core.cpp
    ../XC-OS/APP/Game/Arduboy/audio/: audio.cpp
  group APP/Game/Arduboy2
    ../XC-OS/APP/Game/Arduboy2/: Arduboy2.cpp Arduboy2.h Arduboy2Audio.cpp Arduboy2Beep.cpp Arduboy2Core.cpp Sprites.cpp SpritesB.cpp
  group Game/MicroCity
    ../XC-OS/Game/MicroCity/: MicroCity.cpp Building.cpp Connectivity.cpp Draw.cpp Font.cpp Game.cpp Interface.cpp Simulation.cpp Strings.cpp Terrain.cpp
  group Game/FlightSim
    ../XC-OS/Game/FlightSim/: FlightSim.cpp FixedMath.cpp Font.cpp Game.cpp
  group Game/Ardutosh
    ../XC-OS/Game/Ardutosh/: Ardutosh.cpp Apps.cpp Desktop.cpp Finder.cpp Font.cpp Input.cpp MenuBar.cpp StringWrapper.cpp System.cpp VirtualKeyboard.cpp Window.cpp WindowManager.cpp
  group Game/ArduboyLife
    ../XC-OS/Game/ArduboyLife/: ArduboyLife.cpp
  group Game/ArduboyGraph2
    ../XC-OS/Game/ArduboyGraph2/: graph2.cpp
  group Game/BoneShakers
    ../XC-OS/Game/BoneShakers/: BoneShakers.cpp Draw.cpp FixedMath.cpp Font.cpp Game.cpp
  group Communication
    ../XC-OS/Communication/: ComBasic.cpp ComPrivate.h
  group Communication/RCX
    ../XC-OS/Communication/RCX/Master/: RCX_Package.cpp RCX_Channel.cpp RCX_Handshake.cpp RCX_Passback.cpp RCX.h
    ../XC-OS/Communication/RCX/: crc.cpp RCX_Handshake.h RCX_Type.h
  group LuaInterface
    ../XC-OS/LuaInterface/: LuaBasic.cpp LuaBSP.cpp LuaTime.cpp LuaLVGL.cpp LuaScript.cpp LuaScript.h
  group lua-5.3.2
    ../Libraries/lua-5.3.2/src/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lua.c luac.c lundump.c lutf8lib.c lvm.c lzio.c
  group littlevGL
    ../Libraries/lvgl/src/lv_core/: lv_debug.c lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../Libraries/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../Libraries/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_12_subpx.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_roboto_28_compressed.c lv_font_unscii_8.c
    ../Libraries/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Libraries/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../Libraries/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_cpicker.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../Libraries/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group FreeRTOS
    ../Libraries/FreeRTOS/: FreeRTOSConfig.h
    ../Libraries/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c cpu_utils.c printf-stdarg.c
    ../Libraries/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../Libraries/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group SdFat
    ../Libraries/SdFat/src/FatLib/: FatFile.cpp FatFileLFN.cpp FatFilePrint.cpp FatFileSFN.cpp FatVolume.cpp FmtNumber.cpp fstream.cpp istream.cpp ostream.cpp StdioStream.cpp
    ../Libraries/SdFat/src/SdCard/: SdSpiCard.cpp SdSpiCardEX.cpp SdioCard.cpp SdioCardEX.cpp
    ../Libraries/SdFat/src/SpiDriver/: SdSpiSTM32.cpp
    ../Libraries/SdFat/src/: MinimumSerial.cpp
  group Fatfs
    ../Libraries/FATFS/: diskio.c ff.c Fatfs.cpp
    ../Libraries/FATFS/SdioDriver/: sdio_sd.c
    ../Libraries/FATFS/option/: cc936.c syscall.c
  group mp3
    ../Libraries/mp3/: mp3dec.c mp3tabs.c mp3_convert.c
    ../Libraries/mp3/real/: bitstream.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c buffers.c
    ../Libraries/mp3/real/arm/: asmmisc.s asmpoly_thumb2.s
  group Libraries
    ../Libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    ../Libraries/EEPROM_File/: EEPROM_File.cpp
    ../Libraries/IP5108/: IP5108.cpp
    ../Libraries/I2Cdev/: I2Cdev.cpp
    ../Libraries/MPU6050/: MPU6050.cpp
    ../Libraries/NRF/: NRF_Basic.cpp NRF_TRM.cpp NRF_FHSS.cpp
    ../Libraries/LightGUI/PageManager/: PageManager.cpp
    ../Libraries/FT54X6/: FT54X6.cpp
    ../Libraries/UTFT/: UTFT.cpp
    ../Libraries/BMP280_DEV/: BMP280_DEV.cpp Device.cpp BMP280_DEV.h Device.h
    ../Libraries/ClosedCube_SHT31D/: ClosedCube_SHT31D.cpp
    ../Libraries/SoftwareSPI/: SoftwareSPI.cpp
  group CmBacktrace
    ../Libraries/cm_backtrace/: cm_backtrace.c cmb_cfg.h
    ../Libraries/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp Stream.cpp WString.cpp WMath.cpp HardwareSerial.cpp WireBase.cpp Wire.cpp SPI.cpp Tone.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c pwm.c rng.c timer.c fsmc.c
    ../CORE/: delay.c
  group STM32F4xx_StdPeriph_Driver
    ../Core/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Startup
    ../Core/Startup/ARM/: startup_stm32f429_439xx.s
  group CMSIS
    ../Core/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group README
    ../: README.md
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
